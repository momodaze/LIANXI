#include <REGX52.H>
#include "delay.h"
#include "MatrixLED.h"
#include "74HC595.h"


unsigned char animation[]= {
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0xFF,0x10,0x10,0xFF,0x00,0xFF,0x91,
0x91,0x00,0xFF,0x01,0x01,0x00,0xFF,0x01,
0x01,0x00,0xFF,0x81,0xFF,0x00,0x00,0x0D,
0x0E,0x00,0xFF,0x01,0x1F,0x01,0xFF,0x00,
0xFF,0x81,0xFF,0x00,0xFF,0x98,0xF7,0x01,
0x00,0xFF,0x01,0x01,0x00,0xFF,0x81,0x7E,
0x00,0x00,0xFD,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00
};

void main (){
	unsigned char a,offSet = 0,count = 0;
    Init_LED();
	
	while(1){
		for(a=0;a<8;a++){
			MatrixLED_ShowColor(a,animation[a+offSet]);
		}
		count++;
		if(count==20){
			offSet++;//+8就是逐帧动画
			count = 0;
			if(offSet==58){
				offSet = 0;
			}
		}
	}
}