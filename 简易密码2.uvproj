# Keil uVision project 简易密码2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 简易密码2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./简易密码/: delay.c LCD1602.c main.c matrix.c password.c delay.h LCD1602.h matrix.h password.h
